# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\FreeRTOS;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\src;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\CONTROLLER\CONFIG;.\CONTROLLER\CONTROL;.\HARDWARE\ADC;.\HARDWARE\ENCODER;.\HARDWARE\IIC;.\HARDWARE\MOTOR;.\HARDWARE\MPU6050;.\HARDWARE\USART;.\HARDWARE\INITIALIZE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group FreeRTOS/inc
    ./FreeRTOS/: FreeRTOSConfig.h
    ./FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/port
    ./FreeRTOS/port/: heap_4.c port.c portmacro.h
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group System
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group Controller
    ./CONTROLLER/CONFIG/: config.c
    ./CONTROLLER/CONTROL/: control.c
  group Hardware
    ./HARDWARE/ADC/: adc.c
    ./HARDWARE/ENCODER/: encoder.c
    ./HARDWARE/IIC/: ioi2c.c
    ./HARDWARE/MOTOR/: motor.c
    ./HARDWARE/MPU6050/: mpu6050.c
    ./HARDWARE/USART/: usartx.c
    ./HARDWARE/INITIALIZE/: robot_init.c robot_init.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
